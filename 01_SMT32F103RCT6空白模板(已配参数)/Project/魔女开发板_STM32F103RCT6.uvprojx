# Keil uVision project 魔女开发板_STM32F103RCT6.uvprojx, settings and files
target STM32F103RC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\System\manage;..\Libraries\CMSIS;..\Libraries\CMSIS\startup;..\Libraries\FWlib\inc;..\Libraries\FWlib\src;..\System\delay;..\System\sys;..\System\usart;..\User\GeneralTim;..\User\LED;..\User\speedtext;..\User\tim;..\User\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ../User/: main.c stm32f10x_it.c stm32f10x_conf.h
    ../User/GeneralTim/: bsp_GeneralTim.c
    ../User/LED/: led.c
    ../User/speedtext/: speedtext.c
    ../User/usart/: bsp_usart.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c stm32f10x.h system_stm32f10x.c
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group FWLB
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
