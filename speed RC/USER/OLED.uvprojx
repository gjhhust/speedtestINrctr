# Keil uVision project OLED.uvprojx, settings and files
target QD-OLED (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEST_OLED +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\OLED;.\text;.\tim;.\speedtext;.\LED;.\GeneralTim
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c
    ./speedtext/: speedtext.c
    ./GeneralTim/: bsp_GeneralTim.c
  group HARDWARE
    ./LED/: led.c
    ../HARDWARE/OLED/: oled.c
    ./: startup_stm32f103xe.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ./: system_stm32f10x.c
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c
